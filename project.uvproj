# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F384 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./: STARTUP.A51
    ./src/: main.c scheduler.c processor.c mcu.c heartbeat_task.c uart_task.c
